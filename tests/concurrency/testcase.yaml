## tests/concurrency/testcase.yaml
```yaml
tests:
  rtos_lab.concurrency:
    platform_allow:
      - qemu_cortex_m3
    tags: rtos ztest
```
